Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [notYetAssigned]
Time: 2014-12-07T23:39:46
Author: Jon
Organization: Unknown
Written by: ggIFC - Exporter by Geometry Gym Pty Ltd
Made in: ggIFC - Exporter by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, IfcProject
LongName: IfcProject

# IfcBeamStandardCase: CHS219.1x6.3
In: IfcBuilding
Type - PredefinedType: BEAM; Material: S355JR

# IfcBeamStandardCase: IPE200
In: IfcBuilding
Type - PredefinedType: JOIST; Material: S355JR
