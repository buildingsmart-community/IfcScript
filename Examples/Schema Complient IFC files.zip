Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [notYetAssigned]
Time: 2014-12-07T23:39:46
Author: Jon
Organization: Unknown
Written by: ggIFC - Exporter by Geometry Gym Pty Ltd
Made in: ggIFC - Exporter by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: the geometric representation of the beam is provided as a triangulated face set the meshing depends on the creating software system

# IfcProject, IfcProject
LongName: IfcProject

# IfcBeam, ExampleBeamName
In: IfcBuilding
Description: ExampleBeamDescription
