Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [notYetAssigned]
Time: 2014-12-07T23:38:48
Author: Jon
Organization: Unknown
Written by: ggIFC - Exporter by Geometry Gym Pty Ltd
Made in: ggIFC - Exporter by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, IfcProject
LongName: IfcProject; Document: MyCodeISO3766

# IfcReinforcingBar: 12 Diameter Ligature
In: IfcBuilding
Type - PredefinedType: LIGATURE; NominalDiameter: 12 mm; CrossSectionArea: 113.097; BarLength: 1150 mm; BarSurface: TEXTURED; Material: ReinforcingSteel
